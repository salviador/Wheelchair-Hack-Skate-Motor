# IAR project main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; USER_BUTTON=BSP_PUSH1; CONFIG_HW_LS_RO; BLE_STACK_CUSTOM_CONF; CLIENT; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pe1665
  ICCARM.CCIncludePath2: ; Drivers\Peripherals_Drivers\Inc; Drivers\CMSIS\Device\ST\BlueNRG_LP\Include; Middlewares\ST\hal\Inc; Middlewares\ST\PKAMGR\Inc; Middlewares\ST\RNGMGR\Inc; Middlewares\ST\AESMGR\Inc; Middlewares\ST\BLECNTR\Inc; Drivers\CMSIS\Include; Drivers/BSP/STEVAL-IDB011V1/Inc; Drivers\BSP\Common\Inc; Drivers\BSP\Components\lps22hh_STdC\driver; Drivers\BSP\Components\lsm6dsox_STdC\driver; Middlewares\ST\BLE_Application\layers_inc; Middlewares\ST\Bluetooth_LE\Inc; Middlewares\ST\BLE_Application\OTA\inc; Middlewares\ST\NVMDB\Inc; Middlewares\ST\BLE_Application\Profiles\Inc; Middlewares\ST\cryptolib\inc; Middlewares\ST\cryptolib\inc\Common; Middlewares\ST\cryptolib\inc\AES
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: main.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: adcjoy.c adcjoy.h BLE_GATT_Client.c BLE_GATT_Client.h BLE_GATT_Service_config.h bluenrg_lp_hal_conf.h bluenrg_lp_hal_msp.c bluenrg_lp_it.c bluenrg_lp_it.h Button.c Button.h custom_ble_stack_conf.h disable_all.c disable_all.h led.c led.h main.c main.h vibration.c vibration.h
  group Drivers/BSP
    Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_i2c.c bluenrg_lp_evb_io.c bluenrg_lp_evb_led.c bluenrg_lp_evb_spi.c
    Drivers/BSP/Components/lps22hh_STdC/driver/: lps22hh_reg.c
    Drivers/BSP/Components/lsm6dsox_STdC/driver/: lsm6dsox_reg.c
  group Drivers/CMSIS
    Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    Drivers/Peripherals_Drivers/src/: rf_driver_hal.c rf_driver_hal_adc.c rf_driver_hal_cortex.c rf_driver_hal_dma.c rf_driver_hal_flash.c rf_driver_hal_flash_ex.c rf_driver_hal_gpio.c rf_driver_hal_power_manager.c rf_driver_hal_pwr.c rf_driver_hal_pwr_ex.c rf_driver_hal_rcc.c rf_driver_hal_vtimer.c rf_driver_ll_adc.c rf_driver_ll_crc.c rf_driver_ll_dma.c rf_driver_ll_exti.c rf_driver_ll_flash.c rf_driver_ll_gpio.c rf_driver_ll_i2c.c rf_driver_ll_lpuart.c rf_driver_ll_pka_v7b.c rf_driver_ll_pwr.c rf_driver_ll_radio_2g4.c rf_driver_ll_rcc.c rf_driver_ll_rng.c rf_driver_ll_rtc.c rf_driver_ll_spi.c rf_driver_ll_tim.c rf_driver_ll_timer.c rf_driver_ll_usart.c rf_driver_ll_utils.c
  group Middlewares/AES
    Middlewares/ST/AESMGR/Src/: aes_manager_bluenrg_lp.c
  group Middlewares/BLE_Stack
    Middlewares/ST/Bluetooth_LE/library/: libbluenrg_lp_stack.a
    Middlewares/ST/Bluetooth_LE/src/: stack_user_cfg.c
  group Middlewares/BLECNTR
    Middlewares/ST/BLECNTR/Src/: ble_controller.c ble_controller_bluenrg_lp.c
  group Middlewares/Cryptolib
    Middlewares/ST/cryptolib/: aes_hw.c libcrypto.a
  group Middlewares/Hal
    Middlewares/ST/hal/Src/: blue_unit_conversion.s clock.c context_switch.s gp_timer.c hal_miscutil.c miscutil.c osal.c osal_memcpy.s
  group Middlewares/NVM
    Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/PKA
    Middlewares/ST/PKAMGR/Src/: pka_manager.c pka_manager_bluenrg_lp.c
  group Middlewares/Profiles
    Middlewares/ST/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
  group Middlewares/RNG
    Middlewares/ST/RNGMGR/Src/: rng_manager.c rng_manager_bluenrg_lp.c
